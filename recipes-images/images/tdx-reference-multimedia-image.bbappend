IMAGE_INSTALL_append = " touch-udev-rules\
                        qtquickcontrols2\
                        qtquickcontrols\
                        "
